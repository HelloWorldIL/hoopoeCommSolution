<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_correction</value></param>
<param><key>value</key><value>-1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_offset</value></param>
<param><key>value</key><value>50e3</value></param>
</block>
<block>
<key>ax25_afsk</key>
<param><key>id</key><value>ax25_afsk_0</value></param>
<param><key>baud_rate</key><value>1.2e3</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>rf_samp_rate</key><value>samp_rate_tx</value></param>
<param><key>tx_offset</key><value>tx_offset</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>"localhost"</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>bpsk_ax25_9600bps</key>
<param><key>id</key><value>bpsk_ax25_9600bps_0_0</value></param>
<param><key>baudrate</key><value>9600</value></param>
<param><key>loop_bw</key><value>2*math.pi/200</value></param>
<param><key>excess_bw</key><value>0.5</value></param>
<param><key>max_cfo</key><value>2e3</value></param>
<param><key>rf_samp_rate</key><value>2.4e6</value></param>
<param><key>address</key><value>callsign</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>callsign</value></param>
<param><key>comment</key><value>To avoid the SDR carrier at the DC
we shift the LO a little further</value></param>
<param><key>label</key><value>Sender's Callsign</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"4X4HSL-1"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>channel</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>doppler_port_rx</value></param>
<param><key>label</key><value>Doppler Port RX</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7355</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>doppler_port_tx</value></param>
<param><key>label</key><value>Doppler Port TX</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7356</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>rx_offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gui_bandwidth</value></param>
<param><key>label</key><value>GUI Bandwidth</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>limesdr_sink</key>
<param><key>id</key><value>limesdr_sink_0</value></param>
<param><key>calibr_bandw_ch0</key><value>5e6</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>30</value></param>
<param><key>calibr_bandw_ch1</key><value>5e6</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>gain_dB_ch1</key><value>tx_gain</value></param>
<param><key>pa_path_ch1</key><value>1</value></param>
<param><key>channel_mode</key><value>channel</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>tx_freq-tx_offset+freq_correction</value></param>
<param><key>samp_rate</key><value>samp_rate_tx</value></param>
</block>
<block>
<key>limesdr_source</key>
<param><key>id</key><value>limesdr_source_0</value></param>
<param><key>analog_bandw_ch0</key><value>5e6</value></param>
<param><key>calibr_bandw_ch0</key><value>5e6</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>rx_rf_gain</value></param>
<param><key>analog_bandw_ch1</key><value>5e6</value></param>
<param><key>calibr_bandw_ch1</key><value>5e6</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>gain_dB_ch1</key><value>20</value></param>
<param><key>channel_mode</key><value>channel</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>rx_freq-rx_offset+freq_correction</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>comment</key><value>To avoid the SDR carrier at the DC
we shift the LO a little further</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>gui_bandwidth</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024*4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.04</value></param>
<param><key>wintype</key><value>firdes.WIN_HANN</value></param>
<param><key>ymax</key><value>-80</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>96e3</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024*4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>gui_bandwidth</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>gui_bandwidth</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024*4</value></param>
<param><key>int_max</key><value>-80</value></param>
<param><key>int_min</key><value>-120</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.04</value></param>
<param><key>wintype</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(samp_rate_rx)</value></param>
<param><key>interp</key><value>int(gui_bandwidth)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>436.4e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_rf_gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>70</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_sdr_device</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>usrpb200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>label</key><value>Sample Rate RX</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_tx</value></param>
<param><key>label</key><value>Sample Rate TX</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>satnogs_coarse_doppler_correction_cc</key>
<param><key>id</key><value>satnogs_coarse_doppler_correction_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sampling_rate</key><value>samp_rate_rx</value></param>
<param><key>target_freq</key><value>rx_freq</value></param>
</block>
<block>
<key>satnogs_coarse_doppler_correction_cc</key>
<param><key>id</key><value>satnogs_coarse_doppler_correction_cc_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sampling_rate</key><value>samp_rate_tx</value></param>
<param><key>target_freq</key><value>tx_freq</value></param>
</block>
<block>
<key>satnogs_tcp_rigctl_msg_source</key>
<param><key>id</key><value>satnogs_tcp_rigctl_msg_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>addr</key><value>"127.0.0.1"</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>mode</key><value>True</value></param>
<param><key>port</key><value>doppler_port_rx</value></param>
<param><key>interval</key><value>1000</value></param>
</block>
<block>
<key>satnogs_tcp_rigctl_msg_source</key>
<param><key>id</key><value>satnogs_tcp_rigctl_msg_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>addr</key><value>"127.0.0.1"</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>mode</key><value>True</value></param>
<param><key>port</key><value>doppler_port_tx</value></param>
<param><key>interval</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>145.97e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50e3</value></param>
</block>
<connection><source_block_id>ax25_afsk_0</source_block_id><sink_block_id>limesdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ax25_afsk_0</source_block_id><sink_block_id>satnogs_coarse_doppler_correction_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bpsk_ax25_9600bps_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>0</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>bpsk_ax25_9600bps_0_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>bpsk_ax25_9600bps_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>satnogs_coarse_doppler_correction_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_coarse_doppler_correction_cc_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_coarse_doppler_correction_cc_0_0</source_block_id><sink_block_id>limesdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_tcp_rigctl_msg_source_0</source_block_id><sink_block_id>satnogs_coarse_doppler_correction_cc_0</sink_block_id><source_key>freq</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>satnogs_tcp_rigctl_msg_source_0_0</source_block_id><sink_block_id>satnogs_coarse_doppler_correction_cc_0_0</sink_block_id><source_key>freq</source_key><sink_key>freq</sink_key></connection>
</flow_graph>
