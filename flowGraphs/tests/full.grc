<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>value</key><value>satnogs.not_set_samp_rate_rx</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import satnogs</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>comment</key><value>To avoid the SDR carrier at the DC
we shift the LO a little further</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>ant0</key><value>satnogs.handle_rx_antenna(rx_sdr_device, antenna)</value></param>
<param><key>bb_gain0</key><value>satnogs.handle_rx_bb_gain(rx_sdr_device, satnogs.not_set_rx_bb_gain)</value></param>
<param><key>bw0</key><value>satnogs.handle_samp_rate_rx(rx_sdr_device, samp_rate_rx)</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>freq0</key><value>rx_freq - lo_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>satnogs.handle_rx_if_gain(rx_sdr_device, satnogs.not_set_rx_if_gain)</value></param>
<param><key>gain0</key><value>satnogs.handle_rx_rf_gain(rx_sdr_device, satnogs.not_set_rx_rf_gain)</value></param>
<param><key>args</key><value>soapy=0,driver=lime</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>satnogs.handle_samp_rate_rx(rx_sdr_device, satnogs.not_set_samp_rate_rx)</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_sdr_device</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>usrpb200</value></param>
</block>
<block>
<key>satnogs_bpsk_ax25</key>
<param><key>id</key><value>satnogs_bpsk_ax25_0</value></param>
<param><key>antenna</key><value>satnogs.not_set_antenna</value></param>
<param><key>baudrate</key><value>9600.0</value></param>
<param><key>bb_gain</key><value>satnogs.not_set_rx_bb_gain</value></param>
<param><key>decoded_data_file_path</key><value>"/tmp/.satnogs/data/data"</value></param>
<param><key>dev_args</key><value>satnogs.not_set_dev_args</value></param>
<param><key>doppler_correction_per_sec</key><value>1000</value></param>
<param><key>enable_iq_dump</key><value>0</value></param>
<param><key>excess_bw</key><value>0.5</value></param>
<param><key>file_path</key><value>"test.wav"</value></param>
<param><key>if_gain</key><value>satnogs.not_set_rx_if_gain</value></param>
<param><key>iq_file_path</key><value>"/tmp/iq.dat"</value></param>
<param><key>lo_offset</key><value>100e3</value></param>
<param><key>max_cfo</key><value>1000.0</value></param>
<param><key>ppm</key><value>0</value></param>
<param><key>rf_gain</key><value>satnogs.not_set_rx_rf_gain</value></param>
<param><key>rigctl_port</key><value>4532</value></param>
<param><key>rx_freq</key><value>100e6</value></param>
<param><key>rx_sdr_device</key><value>"usrpb200"</value></param>
<param><key>samp_rate_rx</key><value>satnogs.not_set_samp_rate_rx</value></param>
<param><key>udp_IP</key><value>"127.0.0.1"</value></param>
<param><key>udp_port</key><value>16887</value></param>
<param><key>waterfall_file_path</key><value>"/tmp/waterfall.dat"</value></param>
</block>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>satnogs_bpsk_ax25_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
