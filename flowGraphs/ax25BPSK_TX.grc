<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ax25_bpsk_tx</value></param>
<param><key>category</key><value>[HSL]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>AX25 BPSK TX</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>bpsk</value></param>
<param><key>const_points</key><value>[-1, 1]</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0, 1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>offset</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>rf_samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>label</key><value>Baud Rate (symbols per second)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>blocks_and_const_xx</key>
<param><key>id</key><value>blocks_and_const_xx_0_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>comment</key><value>Multiply const to prevent overmodulation

values should be between 1 and -1</value></param>
<param><key>const</key><value>math.sqrt(2)/2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>comment</key><value>Multiply by 12 Khz to "Move" signal from LO</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_not_xx</key>
<param><key>id</key><value>blocks_not_xx_0_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>comment</key><value>Pack bits.
Example:

Input
00000001 00000000 -&gt;
Output
10</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>callsign</value></param>
<param><key>label</key><value>Callsign</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'4X4HSC'</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>comment</key><value>Perform PSK modulation (BPSK Default)</value></param>
<param><key>constellation</key><value>bpsk</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>0.5</value></param>
<param><key>samples_per_symbol</key><value>int(samp_rate/baud_rate)</value></param>
</block>
<block>
<key>digital_diff_encoder_bb</key>
<param><key>id</key><value>digital_diff_encoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_scrambler_bb</key>
<param><key>id</key><value>digital_scrambler_bb_0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
import time
import pmt
import array
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, preamble_len=16, postamble_len=16, min_time=2.0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Embedded Python Block',   # will show up in GRC
            in_sig=None,
            out_sig=None
        )
        self.preamble_len = preamble_len
        self.postamble_len = postamble_len
        self.min_time = min_time
        self.flag = [np.uint8(0), np.uint8(1), np.uint8(1), np.uint8(1),
        np.uint8(1), np.uint8(1), np.uint8(1), np.uint8(0)]
        self.startTime = time.time()
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.message_port_register_in(pmt.intern('in'))
        self.set_msg_handler(pmt.intern('in'), self.handle_msg)
        self.message_port_register_out(pmt.intern('out'))

    def handle_msg(self, msg_pmt):
        end = time.time()
        msg = pmt.cdr(msg_pmt)
        data = list(pmt.u8vector_elements(msg))
        if (end-self.startTime) &gt; self.min_time:
            buff = self.flag*self.preamble_len + data + self.flag*self.postamble_len
        else:
            buff = self.flag + data + self.flag
        self.startTime = time.time()
        buff = array.array('B', buff)
        self.message_port_pub(pmt.intern('out'), pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(buff), buff)))

    def work(self, input_items, output_items):
        pass
</value></param>
<param><key>min_time</key><value>0.1</value></param>
<param><key>postamble_len</key><value>int(baud_rate*0.1)/8</value></param>
<param><key>preamble_len</key><value>int(baud_rate*0.1)/8</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>offset</value></param>
<param><key>label</key><value>RF Offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50e3</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>bpsk</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>data</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>comment</key><value>Interpolate to RF sample rate</value></param>
<param><key>decim</key><value>int(samp_rate)</value></param>
<param><key>interp</key><value>int(rf_samp_rate)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(2.4e6)</value></param>
</block>
<block>
<key>satellites_hdlc_framer</key>
<param><key>id</key><value>satellites_hdlc_framer_0</value></param>
<param><key>postamble_bytes</key><value>0</value></param>
<param><key>preamble_bytes</key><value>0</value></param>
</block>
<block>
<key>satnogs_ax25_encoder_mb</key>
<param><key>id</key><value>satnogs_ax25_encoder_mb_0</value></param>
<param><key>comment</key><value>Encode Data to AX.25 Packet</value></param>
<param><key>dest_addr</key><value>all</value></param>
<param><key>dest_ssid</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scramble</key><value>True</value></param>
<param><key>postamble_len</key><value>16</value></param>
<param><key>preamble_len</key><value>int(baud_rate*0.1)/8</value></param>
<param><key>src_addr</key><value>callsign</value></param>
<param><key>src_ssid</key><value>ssid</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ssid</value></param>
<param><key>label</key><value>SSID</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_and_const_xx_0_0</source_block_id><sink_block_id>digital_diff_encoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_not_xx_0_0</source_block_id><sink_block_id>blocks_and_const_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>digital_scrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_encoder_bb_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_scrambler_bb_0</source_block_id><sink_block_id>blocks_not_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>satellites_hdlc_framer_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>satnogs_ax25_encoder_mb_0</sink_block_id><source_key>out</source_key><sink_key>info</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>satellites_hdlc_framer_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_ax25_encoder_mb_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
